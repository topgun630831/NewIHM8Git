# IAR project NewIHM8.ewp, settings and files
configuration NewIHM8 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; DEBUG=1
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../embOS_CortexM_IAR_V6_Src_V438/Start/BoardSupport/ST/STM32F429_Discovery/Setup; ../embOS_CortexM_IAR_V6_Src_V438/Start/Inc; ../STemWin/Board/Inc; ../STemWin/Target; ../STemWin/App; ../Middlewares/ST/STemWin/inc; ../Drivers/CMSIS/RTOS/Template; ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NewIHM8.bin
  ILINK.IlinkOutputFile: NewIHM8.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: Version.txt
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group EmbOS/Bsp
    ../embOS_CortexM_IAR_V6_Src_V438/Start/BoardSupport/ST/STM32F429_Discovery/Setup/: BSP.c HardFaultHandler.S JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4x_CMSIS.c SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c
  group EmbOS/Lib
    ../embOS_CortexM_IAR_V6_Src_V438/Start/Lib/: os7m_tlv_dp.a
  group EmWin/App
    ../STemWin/App/: AcbMccbControl.c AcbMccbEvent.c AcbMccbHwSet.c AcbMccbInfo.c AcbMccbMeasurement.c AcbMccbRelaySet.c cyrillic16_16x16.c cyrillic20_20x20.c cyrillic_24x24.c GuiData.c Image.c LS-font16_.c LS-Font20b_.c LS-Font20n_.c LS-font24_.c LS-font_24x24.c MainMenu.c MenuDLG.c MLinkControl.c MLinkEvent.c MLinkHwSet.c MLinkInfo.c MLinkIOSet.c MLinkOverview.c modbus.c PasswordChange.c SettingInput.c SettingTime.c Setup.c
  group EmWin/Board/BackLight
    ../STemWin/Board/backlight/: backlight.c
  group EmWin/Board/Lcd
    ../STemWin/Board/lcd/: lcd.c
  group EmWin/Target
    ../STemWin/Target/: GUIConf.c LCDConf_FlexColor_Hmi.c
  group Middlewares/StemWin
    ../Middlewares/ST/STemWin/OS/GUI_X/: GUI_X_embOS.c
  group Middlewares/StemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_OS_IAR.a
